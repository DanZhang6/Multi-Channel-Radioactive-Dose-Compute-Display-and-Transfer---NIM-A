# Keil uVision project Dose_Proj.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Dose_Proj +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 8253count.c at24c16.c collateral.c lcd.c main.c Masterdisplay.c measure.c reset.c serial.c Serial1Dip.c setinput.c setpara.c settime.c time0.c config.h STC15F2K60S2.h
